options:
  parameters:
    generate_options: qt_gui
    id: AMFM_nosel_v1
    output_language: python
    title: AMFM_nosel_v1
  states: {}

blocks:
- name: AM1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: FM1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: FM1AM8
  id: variable
  parameters:
    comment: |-
      FM IF LP filter
         decimation
    value: 1+(AM1*7)
  states: {}
- name: FM4AM1
  id: variable
  parameters:
    comment: |-
      Baseband FM
      audio, rational
      resampler
      decimation
    value: 1+(FM1*3)
  states: {}
- name: FM6AM48
  id: variable
  parameters:
    comment: |-
      IF waterfall
      bandwidth
    value: 6+(AM1*42)
  states: {}
- name: SDR_rate
  id: variable
  parameters:
    value: 2.304e6
  states: {}
- name: am_ifbw
  id: variable_qtgui_range
  parameters:
    start: '1000'
    step: '500'
    stop: '20000'
    value: '10000'
  states: {state: disabled}
- name: am_ifbw
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: am_xition_width
  id: variable
  parameters:
    value: '500'
  states: {}
- name: audio_filter_coeffs
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '15000'
    gain: '1'
    samp_rate: SDR_rate/6
    width: '1500'
    win: window.WIN_HAMMING
  states: {}
- name: blend_freq
  id: variable
  parameters:
    value: '300'
  states: {}
- name: blend_width
  id: variable
  parameters:
    value: '200'
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: 98.1e6
  states: {}
- name: cent_freq
  id: variable_qtgui_range
  parameters:
    start: 79.9e6
    step: 0.2e6
    stop: 108.1e6
    value: 98.1e6
  states: {state: disabled}
- name: cf_offset
  id: variable
  parameters:
    value: 30e3
  states: {}
- name: decim
  id: variable
  parameters:
    value: '6'
  states: {}
- name: deviation_hz
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: disp_freq
  id: variable
  parameters:
    value: 98.1e6
  states: {}
- name: fm_ifbw
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: fm_xition_width
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: freq_correct
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_speed
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: pilot_carrier_filter_coeffs
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '21000'
    low_cutoff_freq: '17000'
    samp_rate: SDR_rate/6
    type: complex_band_pass
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_msgdigitalnumbercontrol_0
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: qtgui_tab_widget_0@0:0,0,1,1
    lbl: 'Frequency = '
    maxFreqHz: 1700e6
    minFreqHz: '0.0'
    outputmsgname: cent_freq
    readOnly: 'True'
    relBackgroundColor: white
    relFontColor: black
    value: 'disp_freq '
  states: {}
- name: qtgui_msgdigitalnumbercontrol_0_0_0
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: qtgui_tab_widget_0@2:0,0,1,1
    lbl: 'Frequency = '
    maxFreqHz: 1700e6
    minFreqHz: '0.0'
    outputmsgname: cent_freq
    readOnly: 'True'
    relBackgroundColor: white
    relFontColor: black
    value: 'disp_freq '
  states: {}
- name: scroll_speed
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: stereo_carrier_filter_coeffs
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '38400'
    low_cutoff_freq: '37600'
    samp_rate: SDR_rate/6
    type: band_pass
    width: '400'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: volume
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0.5'
    max_gain: '4096'
    rate: '0.07'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_pll_carriertracking_cc_0_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '-0.0654'
    min_freq: '0.0654'
    w: '.05'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2*3.13159*18800/(SDR_rate/6)
    min_freq: 2*3.13159*19200/(SDR_rate/6)
    w: '0.001'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (SDR_rate/6)/(2*math.pi*deviation_hz)
  states: {}
- name: audio_sink_2
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: '35000'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: AM1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: AM1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_var_to_msg_0_1
  id: blocks_var_to_msg
  parameters:
    msgname: send_AM1
    target: AM1
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '512'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: '512'
    long_form: 'True'
    type: ff
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '8'
    taps: audio_filter_coeffs
    type: fff
  states: {}
- name: fft_filter_xxx_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: pilot_carrier_filter_coeffs
    type: ccc
  states: {}
- name: fft_filter_xxx_3
  id: fft_filter_xxx
  parameters:
    decim: '8'
    taps: audio_filter_coeffs
    type: fff
  states: {}
- name: fft_filter_xxx_3_0
  id: fft_filter_xxx
  parameters:
    comment: Low-pass
    decim: '8'
    taps: audio_filter_coeffs
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: cf_offset
    decim: decim
    samp_rate: SDR_rate
    taps: firdes.complex_band_pass(1,SDR_rate,-192e3,192e3,35000)
    type: ccc
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: blend_freq
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: blend_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: FM IF
    cutoff_freq: fm_ifbw/(2)
    decim: FM1AM8
    gain: '1'
    samp_rate: SDR_rate/decim
    type: fir_filter_ccf
    width: fm_xition_width
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: am_ifbw
    decim: '8'
    gain: '1'
    samp_rate: SDR_rate/(6)
    type: fir_filter_ccf
    width: am_xition_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: |-
      FM: deci by 2
      AM: deci by 1 (optional)
    cutoff_freq: '100000'
    decim: '2'
    gain: '1'
    samp_rate: (SDR_rate*9)/(6*12)
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: blend_freq
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_fff
    width: blend_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_1
  id: low_pass_filter
  parameters:
    cutoff_freq: blend_freq
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_fff
    width: blend_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    decim: '8'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    axislabels: 'False'
    color1: '"dark red"'
    comment: 2nd tab, bottom
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1:1,0,1,3
    legend: 'False'
    marker1: '2'
    size: '512'
    type: complex
    update_time: freq_speed
    width1: '3'
    xmax: '1.0'
    xmin: '-1.0'
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: (SDR_rate*3)/(6*4*2)
    comment: 2nd tab, top
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: qtgui_tab_widget_0@1:0,0,1,3
    legend: 'False'
    name: '"FM Baseband"'
    norm_window: 'True'
    type: float
    update_time: freq_speed
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: 48000/8
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    legend: 'False'
    name: '"Audio"'
    norm_window: 'True'
    type: float
    update_time: scroll_speed
    ymax: '-25'
    ymin: '-70'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: SDR_rate
    comment: 1st tab, top
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@0:1,0,1,1
    legend: 'False'
    name: '"Tuner"'
    type: complex
    update_time: freq_speed
    wintype: window.WIN_HAMMING
    ymax: '-30'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: SDR_rate/6
    comment: AM tab, top
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@2:1,0,1,1
    legend: 'False'
    name: '"Tuner"'
    type: complex
    update_time: freq_speed
    wintype: window.WIN_HAMMING
    ymax: '-30'
    ymin: '-110'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: FM
    label1: FM details
    label2: AM
    num_tabs: '3'
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: SDR_rate/(6*8)
    color1: '6'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@2:2,0,3,1
    legend: 'False'
    name: '"IF"'
    type: complex
    update_time: scroll_speed
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: SDR_rate/6
    comment: 1st tab, bottom
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@0:2,0,3,1
    name: '"IF"'
    type: complex
    update_time: scroll_speed
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: FM4AM1
    interp: '3'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: FM5AM1
    type: ccc
  states: {state: bypassed}
- name: sdrplay3_rsp1a_1
  id: sdrplay3_rsp1a
  parameters:
    AGC: 'True'
    agc_set_point: '-30'
    bandwidth: 5000e3
    biasT: 'False'
    center_freq: cent_freq-cf_offset
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: freq_correct
    if_gRdB: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gR: '9'
    rf_notch_filter: 'False'
    rsp_selector: ''
    sample_rate: SDR_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_pll_carriertracking_cc_0_0, '0']
- [analog_fm_deemph_0, '0', blocks_selector_0, '0']
- [analog_fm_deemph_0_0, '0', blocks_selector_0_0, '0']
- [analog_fm_deemph_0_0, '0', low_pass_filter_1_1_0, '0']
- [analog_pll_carriertracking_cc_0_0, '0', blocks_complex_to_mag_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_1, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_multiply_xx_1, '0']
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_1, '0']
- [analog_quadrature_demod_cf_0, '0', fft_filter_xxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', fft_filter_xxx_3_0, '0']
- [blocks_add_xx_0, '0', low_pass_filter_1_0, '0']
- [blocks_add_xx_0_0, '0', analog_fm_deemph_0_0, '0']
- [blocks_add_xx_0_1, '0', analog_fm_deemph_0, '0']
- [blocks_complex_to_mag_0, '0', dc_blocker_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_delay_2, '0', qtgui_const_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', blocks_delay_2, '0']
- [blocks_float_to_complex_1, '0', fft_filter_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_2, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_2, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_1, '0', fft_filter_xxx_3, '0']
- [blocks_selector_0, '0', blocks_float_to_complex_0, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_selector_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_selector_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_sub_xx_0, '0', low_pass_filter_1_1, '0']
- [blocks_var_to_msg_0_1, msgout, blocks_selector_0, iindex]
- [blocks_var_to_msg_0_1, msgout, blocks_selector_0_0, iindex]
- [dc_blocker_xx_0, '0', blocks_selector_0, '1']
- [dc_blocker_xx_0, '0', blocks_selector_0_0, '1']
- [dc_blocker_xx_1, '0', rational_resampler_xxx_0, '0']
- [fft_filter_xxx_0, '0', blocks_add_xx_0, '0']
- [fft_filter_xxx_0, '0', blocks_sub_xx_0, '0']
- [fft_filter_xxx_1, '0', analog_pll_refout_cc_0, '0']
- [fft_filter_xxx_3, '0', blocks_add_xx_0, '1']
- [fft_filter_xxx_3, '0', blocks_sub_xx_0, '1']
- [fft_filter_xxx_3_0, '0', high_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [high_pass_filter_0, '0', blocks_add_xx_0_0, '1']
- [high_pass_filter_0, '0', blocks_add_xx_0_1, '1']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0_0_0_0, '0']
- [low_pass_filter_0_0, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_1_0, '0', blocks_add_xx_0_0, '0']
- [low_pass_filter_1_1, '0', blocks_add_xx_0_1, '0']
- [low_pass_filter_1_1_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [sdrplay3_rsp1a_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [sdrplay3_rsp1a_1, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
